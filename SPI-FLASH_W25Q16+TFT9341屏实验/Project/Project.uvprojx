# Keil uVision project Project.uvprojx, settings and files
target SPI-FLASH_W25Q16+9341屏实验 (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: SPI Flash +hex
  c flags: OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_CL
  c include: ..\Libraries\CMSIS\CoreSupport;..\Libraries\CMSIS\DeviceSupport;..\Libraries\CMSIS\DeviceSupport\Startup;..\Libraries\STM32F10x_StdPeriph_Driver_V3.5\inc;..\Libraries\STM32F10x_StdPeriph_Driver_V3.5\src;..\User\Main;..\User\Delay;..\User\Led;..\User\Lcd
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User/Main
    ../User/Main/: main.c stm32f10x_it.c hw_config.c DS18B20.c w25q16.c
    ../Libraries/STM32F10x_StdPeriph_Driver_v3.5/src/: stm32f10x_adc.c
  group Libraries/StdPeriph_Driver
    ../Libraries/STM32F10x_StdPeriph_Driver_V3.5/src/: stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c
    ../Libraries/STM32F10x_StdPeriph_Driver_v3.5/src/: stm32f10x_exti.c stm32f10x_spi.c
  group Libraries/CMSIS
    ../Libraries/CMSIS/CoreSupport/: core_cm3.c
    ../Libraries/CMSIS/DeviceSupport/Startup/: startup_stm32f10x_cl.s
    ../Libraries/CMSIS/DeviceSupport/: system_stm32f10x.c
  group Lcd
    ../User/Lcd/: lcd.c
  group Delay
    ../User/Delay/: delay.c
  group Doc
    ../Doc/: information.txt
