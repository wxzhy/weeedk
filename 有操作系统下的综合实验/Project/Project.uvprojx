# Keil uVision project Project.uvprojx, settings and files
target 有操作系统下的综合实验 (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: OS下综合实验 +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_CL
  c include: ..\Libraries\CMSIS\CoreSupport;..\Libraries\CMSIS\DeviceSupport;..\Libraries\CMSIS\DeviceSupport\Startup;..\Libraries\STM32F10x_StdPeriph_Driver_v3.5\inc;..\Libraries\STM32F10x_StdPeriph_Driver_v3.5\src;..\User;..\UCOSII\port;..\UCOSII\src;..\UCOSII\uC-CPU
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ../User/: main.c hw_config.c stm32f10x_it.c lcd.c
  group StdPeriph_Driver
    ../Libraries/STM32F10x_StdPeriph_Driver_v3.5/src/: stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_adc.c stm32f10x_dac.c stm32f10x_dma.c
  group CMSIS
    ../Libraries/CMSIS/CoreSupport/: core_cm3.c
    ../Libraries/CMSIS/DeviceSupport/: system_stm32f10x.c
    ../Libraries/CMSIS/DeviceSupport/Startup/: startup_stm32f10x_cl.s
  group ucos/source
    ../UCOSII/src/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group ucos/port
    ../UCOSII/port/: os_cpu_c.c os_dbg.c os_cpu.h os_cpu_a.asm
  group ucos/CPU
    ../UCOSII/uC-CPU/: cpu.h cpu_a.asm cpu_def.h
  group Readme
    ../Doc/: Readme.txt
